# Keil uVision project MPU6050_PWM.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MPU6050_PWM
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\HcubedLib\MPU6050(kalman);..\..\..\HcubedLib\Delay_sys;..\..\..\HcubedLib\GPIO_init
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: main.c
  group mpu6050
    ../../../HcubedLib/MPU6050(kalman)/: mpu6050.c mpu6050.h
  group delay
    ../../../HcubedLib/Delay_sys/: Delay_sys.c Delay_sys.h
  group GPIO
    ../../../HcubedLib/GPIO_init/: GPIO_Drive.c GPIO_Drive.h
  group pid_controller
    ./: H_pid.c H_pid.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0
