# Keil uVision project TFT_ili9225.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TFT_ili9225
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\HcubedLib\ili9225_lib;..\..\..\HcubedLib\SPI;..\..\..\HcubedLib\GPIO_init
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: main.c
  group ili9225
    ../../../HcubedLib/ili9225_lib/: ILI9225.c ILI9225.h
  group spi
    ../../../HcubedLib/SPI/: SPI_Drive.c SPI_Drive.h
    ../../../HcubedLib/GPIO_init/: GPIO_Drive.c GPIO_Drive.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0
