# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\HcubedLib\LCD;..\..\HcubedLib\Delay;..\..\HcubedLib\GPIO_Setup(resgister);..\..\HcubedLib\USART
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source
    ./: main.c
  group LCD
    ../../HcubedLib/LCD/: i2c.c i2c.h i2c_lcd.c i2c_lcd.h PCF8574.c PCF8574.h
  group delay
    ../../HcubedLib/Delay/: delay.c delay.h
  group GPIO_Setup
    ../../HcubedLib/GPIO_Setup(resgister)/: gp_drive.c gp_drive.h
  group bluetooth
    ../../HcubedLib/USART/: USART.c USART.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
